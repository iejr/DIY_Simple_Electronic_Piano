# Keil uVision project test1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: test1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 F120_Oscillators.c F120_UART0.c main.c F120_Midi.c
